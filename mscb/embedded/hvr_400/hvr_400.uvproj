# Keil uVision project hvr_400.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F310 Cygnal Integrated Products
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: hvr_400 +hex
  c flags: Optimize=9
  c include: ..\include
  group Source Group 1
    ./: hvr_400.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ../include/: mscbemb.h
    ./: config.h
