# Keil uVision project scs_2001_app.uvproj, settings and files
target ICE (MCS-51)
  device: C8051F121 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000)
  output: scs_2001_rfbeta +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: \midas\mscb\embedded\include;\midas\mscb\embedded\scs_2001\
  group Source Files
    ../../: lcd_menu.c monitor.c rtc.c scs_2001_lib.c
    ../../../src/: mscbmain.c mscbutil.c
    ./: scs_2001_rfbeta.c
  group Include Files
    ./: config.h
    ../../: scs_2001.h
    ../../../include/: mscbemb.h
target Simulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: scs_2000_app
  c flags: Optimize=8 SizeSpeed=1
  c define: SCS_2000
