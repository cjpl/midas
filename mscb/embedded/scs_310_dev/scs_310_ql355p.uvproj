# Keil uVision project scs_310_ql355p.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F021 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: scs_310_ql355p +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Soure Files
    ./: scs_310_ql355p.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ./: config.h
    ../include/: mscbemb.h
