# Keil uVision project scs_210_pds60.uvproj, settings and files
target Simulator (MCS-51)
  device: C8051F121 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: scs_210_pds60 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Source Files
    ./: scs_210_pds60.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ./: config.h
    ../include/: mscbemb.h
target ICE (MCS-51)
  device: C8051F020/021 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0xFFF) IROM(0 - 0xFFFF) CLOCK(25000000)
  output: scs_210 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SCS_210
