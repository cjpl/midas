# Keil uVision project scs_210_tpg262.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020/021 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0xFFF) IROM(0 - 0xFFFF) CLOCK(25000000)
  output: scs_210_tpg262 +hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\include
  group Source Files
    ./: scs_210_tpg262.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ./: config.h
    ../include/: mscbemb.h
