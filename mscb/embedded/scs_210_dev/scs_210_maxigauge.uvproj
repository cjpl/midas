# Keil uVision project scs_210_maxigauge.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020/021 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0xFFF) IROM(0 - 0xFFFF) CLOCK(25000000)
  output: scs_210_maxigauge +hex
  c flags: Optimize=4 SizeSpeed=1
  c include: \midas\mscb\embedded\include
  group Source Files
    ../src/: mscbmain.c mscbutil.c
    ./: scs_210_maxigauge.c
  group Include Files
    ../include/: mscbemb.h
    ./: config.h
