# Keil uVision project scs_2000_led.uvproj, settings and files
target ICE (MCS-51)
  device: C8051F121 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000)
  output: scs_2000_led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: \midas\mscb\embedded\include
  group Source Files
    ./: scs_2000_led.c scs_2000_ledlib.c
    ../../../src/: mscbmain.c mscbutil.c
    ../../../scs_2000/: lcd_menu.c
  group Include Files
    ./: scs_2000_led.h config.h
    ../../../include/: mscbemb.h
target Simulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: scs_500
  c flags: Optimize=8 SizeSpeed=1
  c define: SCS_500
