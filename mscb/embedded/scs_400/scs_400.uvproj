# Keil uVision project scs_400.uvproj, settings and files
target Simulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: scs_400 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Source Files
    ./: scs_400.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ../include/: mscbemb.h
    ./: config.h
target Emulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: scs_400 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SCS_400
