# Keil uVision project hvr_test.uvproj, settings and files
target Simulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: hvr_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Source Files
    ./: hvr_test.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ./: config.h
    ../include/: mscbemb.h
target Emulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: HVR_TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: HVR_TEST
