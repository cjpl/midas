# Keil uVision project scs_600.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: scs_600 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Soure Files
    ../src/: mscbutil.c mscbmain.c
    ./: scs_600.c
  group Include Files
    ./: config.h
    ../include/: mscbemb.h
