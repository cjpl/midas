# Keil uVision project scs_920.uvproj, settings and files
target ICE (MCS-51)
  device: C8051F005 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(20000000)
  output: scs_920 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Source Files
    ../src/: mscbmain.c
    ./: scs_920.c
    ../include/: mscbemb.h
  group Include Files
    ../src/: mscbutil.c
    ./: config.h
target Simulator (MCS-51)
  device: C8051F000/001/002 Cygnal Integrated Products
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF) CLOCK(20000000)
  output: scs_500
  c flags: Optimize=8 SizeSpeed=1
  c define: SCS_500
