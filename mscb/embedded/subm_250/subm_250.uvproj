# Keil uVision project subm_250.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F320 Cygnal Integrated Products
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: subm_250 +hex
  c flags: Optimize=9
  c include: ..\include
  group Source
    ./: subm_250.c
    ../src/: mscbutil.c usb.c
  group Headers
    ./: config.h
    ../include/: mscbemb.h usb.h
