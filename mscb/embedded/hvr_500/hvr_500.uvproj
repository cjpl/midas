# Keil uVision project hvr_500.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F310 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: hvr_500 +hex
  c flags: Optimize=9
  c include: ..\include
  group Source Group 1
    ./: hvr_500.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ./: config.h
    ../include/: mscbemb.h
