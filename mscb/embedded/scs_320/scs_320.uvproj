# Keil uVision project scs_320.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F320 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: scs_320 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include
  group Soure Files
    ./: scs_320.c
    ../src/: mscbmain.c mscbutil.c
  group Include Files
    ../include/: mscbemb.h
    ./: config.h
